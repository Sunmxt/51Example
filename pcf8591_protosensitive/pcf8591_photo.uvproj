# Keil uVision project pcf8591_photo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: pcf8591_photo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: pcf8591_photo.c i2c.c pcf8591.c
