# Keil uVision project pwm_moto.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: pwm_moto +hex
  c flags: Optimize=9 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: pwm_moto.c utils.c
